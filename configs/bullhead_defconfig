## configs/bullhead_defconfig
```kconfig
CONFIG_CROSS_COMPILE="aarch64-linux-gnu-"
CONFIG_QCOM_MSM8994=y
CONFIG_LG_BULLHEAD=y
```
